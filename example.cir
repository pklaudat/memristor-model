*****************************************************************************************
*						Exemplo - Modelo de memristor									*
*****************************************************************************************
simulator lang=spectre
include "32nm_hp.pm"
include "memristor.scs"

VDD node 0 vsource type=pwl wave=[0 1u 10n 1u 10.01n 1 20n 1 20.01n 1u 30n 1u 30.01n -1 40n -1 40.01n 1u]
VSS node2 0 vsource dc=0
XR1 node node2 memristor

mytran tran stop=60n start=500p

***********************************************************************
